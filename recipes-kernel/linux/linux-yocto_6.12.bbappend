require linux-yocto-amd-zynq.inc

KBRANCH:amd-zynq  = "v6.12/standard/xlnx-soc"
